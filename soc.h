#pragma once
// ===========================================================================
//  soc.h — ВІДСОТОК ЗАРЯДУ ЗА НАПРУГОЮ ДЛЯ 2S-ПАКЕТА
// ===========================================================================
//  Що було не так. Відсоток рахувався ЛІНІЙНО між двома числами:
//
//      p = (mv - 6350) * 100 / (8250 - 6350)
//
//  Для літій-іонного пакета це неправильно не «на кілька відсотків», а
//  принципово: крива напруги спокою (OCV) у літію — не пряма, а полога сходинка
//  з довгим плато посередині й крутими краями. Ось що давала лінійка проти
//  реального стану 2S-пакета:
//
//      напруга    лінійно    насправді    похибка
//      6.60 В       13 %         2 %       +11
//      7.00 В       34 %        ~8 %       +26   ← пакет майже сів
//      7.20 В       45 %        20 %       +25
//      7.40 В       55 %        45 %       +10
//      8.00 В       87 %        80 %        +7
//
//  Тобто найгірше саме там, де ціна помилки найвища: пристрій показував «третину
//  заряду» на пакеті, якому лишалось кілька відсотків. Причина проста —
//  посередині справжня крива йде майже горизонтально (7.20…7.36 В це цілих
//  20 % заряду, усього 160 мВ), а лінійка розтягує ці 160 мВ на 8 %.
//
//  ⚑ МЕЖІ ТЕПЕР БЕРУТЬСЯ З ХІМІЇ, А НЕ З ПІДІБРАНИХ ЧИСЕЛ.
//      0 %   = 3.00 В на банку = 6.00 В на пакеті (нижче працює захист пакета);
//      100 % = 4.20 В на банку = 8.40 В на пакеті (паспортний максимум літію).
//  Старі 6.35 / 8.25 В не відповідали ні тому, ні тому.
//
//  ⚠️ ЩО ЦЕ ОЗНАЧАЄ ДЛЯ ЗАРЯДУ ДО 8.2 В. 8.20 В — це 4.10 В на банку, а це за
//  кривою рівно 90 %, і так воно й є насправді: заряд до 4.10 В/банку свідомо
//  недобирає останню десяту частину заради ресурсу. Тож після «повного» заряду
//  шкала показуватиме ~90 %, і це не похибка, а чесне число. Щоб бачити 100 %,
//  довелося б піднімати CHARGE_TARGET_MV до 8400 — ціною ресурсу банок.
//
//  ⚑ І ЩЕ ОДНЕ, ПРО ЩО ЛЕГКО ЗАБУТИ. OCV — це напруга СПОКОЮ. Під навантаженням
//  вона просідає, під зарядом завищена, тож відсоток за напругою правдивий лише
//  на відпочилому пакеті. Саме тому і заряд, і розряд міряють напругу на
//  ЗАКРИТОМУ ключі з витримкою, а там, де є справний лічильник ICA всередині
//  пакета, показ береться з нього, а не звідси (див. batteryPercent()).
//
//  Тут — чиста арифметика без вводу-виводу, щоб її перевіряв хостовий тест.
// ===========================================================================

#include <stdint.h>

// Скільки банок послідовно. Пакети IMPRES цієї родини — 2S (по 3 елементи
// паралельно в банці, але на напругу це не впливає).
#ifndef SOC_CELLS
  #define SOC_CELLS 2
#endif

// Крива напруги спокою ОДНІЄЇ банки: мВ -> % заряду. Табличка типова для
// літій-іонних елементів і зумисне зберігається ПОБАНКОВО: перерахунок на
// пакет — це множення на SOC_CELLS, тож та сама крива годиться і для 3S, якщо
// колись знадобиться.
struct SocPoint { uint16_t cellMv; uint8_t pct; };

// ⚑ КРАЇ КРИВОЇ — ОКРЕМИМИ ЛІТЕРАЛАМИ, І ЦЕ ВИМУШЕНО.
//  Спокуса була взяти їх прямо з таблиці: SOC_CURVE[0].cellMv. Але ці межі
//  читає ще й препроцесор — на них спираються #if-перевірки в settings.h, — а
//  препроцесор не вміє ні індексувати масив, ні читати поле структури: він
//  чесно каже «token "[" is not valid in preprocessor expressions». Той самий
//  клас пастки, що й спроба порахувати sizeof() у #if.
//  Тому межі — літерали, а static_assert нижче не дає їм розійтися з таблицею.
#define SOC_CELL_EMPTY_MV 3000     // 0 %   — нижче працює захист пакета
#define SOC_CELL_FULL_MV  4200     // 100 % — паспортний максимум літію

static constexpr SocPoint SOC_CURVE[] = {   // constexpr — щоб таблицю бачив static_assert
    { SOC_CELL_EMPTY_MV, 0 },   // нижче — працює захист пакета, рахувати нічого
    { 3390,   5 },
    { 3480,  10 },
    { 3550,  15 },
    { 3600,  20 },
    { 3620,  25 },   // ── початок плато: 160 мВ на цілих 20 % заряду ──
    { 3640,  30 },
    { 3660,  35 },
    { 3680,  40 },
    { 3710,  45 },
    { 3740,  50 },
    { 3770,  55 },
    { 3800,  60 },   // ── кінець плато ──
    { 3850,  65 },
    { 3900,  70 },
    { 3950,  75 },
    { 4000,  80 },
    { 4050,  85 },
    { 4100,  90 },   // ← саме сюди потрапляє заряд до 8.20 В на пакеті
    { 4150,  95 },
    { SOC_CELL_FULL_MV, 100 },
};
#define SOC_POINTS ((int)(sizeof(SOC_CURVE) / sizeof(SOC_CURVE[0])))

// Межі шкали В ПЕРЕРАХУНКУ НА ПАКЕТ. Змінити хімію — це змінити два числа
// вище, і все інше поїде за ними.
#define SOC_EMPTY_MV (SOC_CELL_EMPTY_MV * SOC_CELLS)
#define SOC_FULL_MV  (SOC_CELL_FULL_MV  * SOC_CELLS)

// Таблиця мусить починатись на 0 % і закінчуватись на 100 % рівно тими самими
// напругами, які бачить препроцесор. Інакше шкала й перевірки в settings.h
// говорили б про різні пакети.
static_assert(SOC_CURVE[0].pct == 0, "крива мусить починатись з 0 %");
static_assert(SOC_CURVE[SOC_POINTS - 1].pct == 100, "…і закінчуватись на 100 %");
static_assert(SOC_CURVE[0].cellMv == SOC_CELL_EMPTY_MV, "нижній край розійшовся з таблицею");
static_assert(SOC_CURVE[SOC_POINTS - 1].cellMv == SOC_CELL_FULL_MV, "верхній край розійшовся");

// Напруга ПАКЕТА -> відсоток. Кусково-лінійна інтерполяція між вузлами.
inline int socPctFromMv(int packMv) {
    long cell = (long)packMv / SOC_CELLS;
    if (cell <= SOC_CURVE[0].cellMv) return 0;
    if (cell >= SOC_CURVE[SOC_POINTS - 1].cellMv) return 100;
    for (int i = 1; i < SOC_POINTS; i++) {
        if (cell <= (long)SOC_CURVE[i].cellMv) {
            long v0 = SOC_CURVE[i - 1].cellMv, v1 = SOC_CURVE[i].cellMv;
            long p0 = SOC_CURVE[i - 1].pct,    p1 = SOC_CURVE[i].pct;
            // +((v1-v0)/2) — округлення до найближчого, а не вниз: інакше
            // шкала систематично занижувала б на пів відсотка на кожному вузлі.
            return (int)(p0 + ((cell - v0) * (p1 - p0) + (v1 - v0) / 2) / (v1 - v0));
        }
    }
    return 100;
}

// Обернена функція: відсоток -> напруга ПАКЕТА. Потрібна, щоб вибирати ціль
// заряду у відсотках. Крива монотонна, тож обернення однозначне.
inline int socMvFromPct(int pct) {
    if (pct <= 0) return SOC_EMPTY_MV;
    if (pct >= 100) return SOC_FULL_MV;
    for (int i = 1; i < SOC_POINTS; i++) {
        if (pct <= (int)SOC_CURVE[i].pct) {
            long v0 = SOC_CURVE[i - 1].cellMv, v1 = SOC_CURVE[i].cellMv;
            long p0 = SOC_CURVE[i - 1].pct,    p1 = SOC_CURVE[i].pct;
            long cell = v0 + ((long)(pct - p0) * (v1 - v0) + (p1 - p0) / 2) / (p1 - p0);
            return (int)(cell * SOC_CELLS);
        }
    }
    return SOC_FULL_MV;
}
