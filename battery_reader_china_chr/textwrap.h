#pragma once
// ===========================================================================
//  textwrap.h — ТЕКСТ НЕ СМІЄ ВИЛІЗТИ ЗА МЕЖІ ТОГО, У ЧОМУ ЙОГО МАЛЮЮТЬ
// ===========================================================================
//  Скарга: «в банері помилки живлення частина тексту вилазить за межі банера».
//  Так і було, причому не на піксель. Панель — 240 px, плашка — 236 px, а
//  рядок «блок живлення просів або не той» це 31 гліф шрифтом 9x15, тобто
//  279 px. Текст не просто вилазив за плашку — він не вміщався в САМ ЕКРАН, а
//  центрування (TFT_W - ширина)/2 при від'ємному результаті ще й зсувало його
//  початок ліворуч за край.
//
//  ⚑ ЧОМУ НЕ ПРОСТО «СКОРОТИТИ РЯДОК». Скорочення тримається рівно до
//  наступної правки тексту. Порахувати гліфи очима ніхто не буде — тим паче
//  що в UTF-8 кирилична літера це два байти, тож навіть strlen() тут бреше
//  рівно вдвічі. Потрібен механізм, а не акуратність.
//
//  Тут — чиста арифметика без вводу-виводу, щоб її перевіряв хостовий тест:
//  display_color.h на хості не збирається (Adafruit GFX, U8g2), і все, що
//  написано всередині нього, не покриває жоден тест.
//
//  ⚑ ЧОМУ РАХУНОК У ГЛІФАХ, А НЕ В ПІКСЕЛЯХ. Усі шрифти, якими цей проєкт
//  малює текст, — МОНОШИРИННІ (u8g2 4x6, 5x8, 6x12, 7x13, 8x13, 9x15, 10x20).
//  Для них ширина в пікселях це рівно «гліфів × ширина комірки», тож рахунок
//  у гліфах не наближення, а точна відповідь — і та сама на хості й на ESP32.
// ===========================================================================

#include <stdint.h>
#include <stddef.h>

// Скільки ГЛІФІВ у рядку UTF-8. Продовжувальні байти (10xxxxxx) не рахуємо.
inline int txtGlyphs(const char *s) {
    if (!s) return 0;
    int n = 0;
    for (const unsigned char *p = (const unsigned char *)s; *p; p++)
        if ((*p & 0xC0) != 0x80) n++;
    return n;
}

// Зсув у БАЙТАХ, на якому починається гліф номер g (0-based). Якщо гліфів
// менше — повертає довжину рядка в байтах.
inline int txtByteAt(const char *s, int g) {
    if (!s) return 0;
    int n = 0, i = 0;
    for (const unsigned char *p = (const unsigned char *)s; *p; p++, i++) {
        if ((*p & 0xC0) != 0x80) { if (n == g) return i; n++; }
    }
    return i;
}

// Один рядок після розбиття: зсув і довжина В БАЙТАХ + скільки в ньому гліфів.
struct TxtLine { int off, len, glyphs; };

// Розбити рядок так, щоб у кожному шматку було не більше maxGlyphs гліфів.
// Ламаємо по пробілах; слово, довше за рядок, ріжемо жорстко (інакше воно
// вилізе — а саме цього ми й уникаємо). Пробіл на місці розриву не переносимо.
// Повертає кількість заповнених рядків (не більше maxLines).
//
// Якщо текст не вміщається у maxLines рядків, останній рядок обривається: це
// свідоме рішення. Обрізаний текст видно як обрізаний, а текст, що вилазить за
// плашку, читається як зіпсований екран.
inline int txtWrap(const char *s, int maxGlyphs, TxtLine *out, int maxLines) {
    if (!s || !out || maxLines <= 0 || maxGlyphs <= 0) return 0;
    int total = txtGlyphs(s);
    int lines = 0, gPos = 0;
    while (gPos < total && lines < maxLines) {
        int left = total - gPos;
        int take = left <= maxGlyphs ? left : maxGlyphs;
        if (take == maxGlyphs && left > maxGlyphs) {
            // Шукаємо останній пробіл у межах рядка, щоб зламати по слову.
            int br = -1;
            for (int g = take; g > 0; g--) {
                int b = txtByteAt(s, gPos + g);
                if (s[b] == ' ') { br = g; break; }
            }
            // Пробіл рівно на межі теж годиться — слово скінчилось саме тут.
            if (br > 0) take = br;
        }
        int b0 = txtByteAt(s, gPos);
        int b1 = txtByteAt(s, gPos + take);
        out[lines].off = b0;
        out[lines].len = b1 - b0;
        out[lines].glyphs = take;
        lines++;
        gPos += take;
        // З'їдаємо пробіли на початку наступного рядка.
        while (gPos < total && s[txtByteAt(s, gPos)] == ' ') gPos++;
    }
    return lines;
}

// Чи вміщається рядок у задану ширину БЕЗ переносу. Саме це питання ставить
// хостовий тест до штатних написів: перенос — запобіжник, а не спосіб верстки.
inline bool txtFits(const char *s, int maxGlyphs) {
    return txtGlyphs(s) <= maxGlyphs;
}
