#ifndef SNAPSHOT_DIFF_H
#define SNAPSHOT_DIFF_H
// ===========================================================================
//  snapshot_diff.h — ЩО САМЕ ЗМІНИЛА СТАНЦІЯ. ПОБАЙТОВО.
// ===========================================================================
//  Історія, заради якої це написано, тягнеться через увесь проєкт: власник
//  обнуляє лічильники, ставить пакет у зарядку, дістає — і числа повернулись.
//  Щоразу ми знаходили ЩЕ ОДНЕ місце, де пакет тримав ту саму пам'ять:
//
//      1) ETM у DS2438                        — знали з початку
//      2) дві мітки подій у секундах (0x10/0x14) — 3.30
//      3) CCA/DCA у блоці NONSMART DS2433       — 3.40
//      4) третя мітка, у добах (0x32)           — 3.53
//
//  І щоразу шлях до знахідки був один і той самий: власник називає число,
//  ми перебираємо корпус і шукаємо, звідки воно могло взятись. Це коштує днів
//  і працює лише тоді, коли потрібне поле вже є в чиємусь дампі.
//
//  ⚑ ЗАМІСТЬ ЦЬОГО — ПРЯМЕ ВИМІРЮВАННЯ. Зняли знімок обох чипів ДО станції,
//  зняли після — і подивились, ЯКІ САМЕ БАЙТИ вона змінила. П'яте місце (якщо
//  воно є) знайдеться за один захід, а не за три листування, і знайдеться
//  навіть тоді, коли в корпусі такого дампа немає взагалі.
//
//  ⚑ ЧОМУ ПОБАЙТОВО, А НЕ «ПО ПОЛЯХ». Поля ми показуємо теж — але саме вони й
//  є те, що ми ВЖЕ знаємо. Поле, якого ми не знаємо, у список полів не
//  потрапить за визначенням, і різниця по полях його не покаже. Тому основа —
//  сирі байти, а імена полів лише підписують ті з них, які нам відомі.
// ===========================================================================

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define SNAP_MAX_RUNS 24     // скільки ділянок різниці показуємо

// Одна ділянка різниці: суцільний прогін змінених байтів.
struct SnapRun {
    uint16_t at;             // зсув першого зміненого байта
    uint8_t  len;            // скільки байтів поспіль
};

struct SnapDiff {
    SnapRun runs[SNAP_MAX_RUNS];
    int     n;               // скільки ділянок записано
    int     total;           // скільки байтів змінилось УСЬОГО
    bool    truncated;       // ділянок було більше, ніж влізло
};

// Порівняти два образи одного чипа. Сусідні змінені байти збираються в один
// прогін: «змінились 0x32 і 0x33» — це одне число, а не дві новини.
//
//  ⚑ АЛЕ ПРОГІН РВЕТЬСЯ НА МЕЖІ ПОЛЯ — І САМЕ ЦЕ НАЙВАЖЛИВІШЕ. Ім'я прогону
//  береться з його ПОЧАТКУ; якби прогін вільно переповзав у сусідній байт,
//  зміна 0x32..0x35 приїхала б підписаною «МІТКА 3 (доби)» — хоча мітка це
//  лише 0x32..0x33, а 0x34 ми не знаємо взагалі. Тобто рівно та знахідка,
//  заради якої все й написано, приїхала б під чужим, заспокійливим іменем.
//  Тому там, де змінюється підпис, починається новий прогін.
//
//  nameOf може бути nullptr — тоді прогін рветься лише на однакових байтах.
inline void snapDiffBytes(const uint8_t *a, const uint8_t *b, int len, SnapDiff &d,
                          const char *(*nameOf)(int) = nullptr) {
    memset(&d, 0, sizeof(d));
    int i = 0;
    while (i < len) {
        if (a[i] == b[i]) { i++; continue; }
        int start = i;
        const char *n0 = nameOf ? nameOf(start) : "";
        i++;
        while (i < len && a[i] != b[i] && (i - start) < 255) {
            if (nameOf && strcmp(nameOf(i), n0) != 0) break;
            i++;
        }
        d.total += (i - start);
        if (d.n < SNAP_MAX_RUNS) {
            d.runs[d.n].at  = (uint16_t)start;
            d.runs[d.n].len = (uint8_t)(i - start);
            d.n++;
        } else {
            d.truncated = true;
        }
    }
}

// ⚑ ПІДПИС ДЛЯ ЗСУВУ — ЛИШЕ ТАМ, ДЕ МИ СПРАВДІ ЗНАЄМО, ЩО ЦЕ. Вигадати назву
//  невідомому байту означало б заховати саме те, заради чого все й робиться:
//  «невідомий байт змінився» — це новина, а «щось із конфігурації» — ні.
inline const char *snapName38(int at) {
    if (at == 0x00)                 return "статус/конфіг";
    if (at >= 0x01 && at <= 0x02)   return "температура";
    if (at >= 0x03 && at <= 0x04)   return "напруга";
    if (at >= 0x05 && at <= 0x06)   return "струм";
    if (at == 0x07)                 return "поріг";
    if (at >= 0x08 && at <= 0x0B)   return "НАРОБІТОК (ETM)";
    if (at == 0x0C)                 return "паливомір ICA";
    if (at >= 0x0D && at <= 0x0E)   return "калібрування АЦП";
    if (at >= 0x10 && at <= 0x13)   return "МІТКА 1 (секунди)";
    if (at >= 0x14 && at <= 0x17)   return "МІТКА 2 (секунди)";
    if (at >= 0x18 && at <= 0x31)   return "дзеркало ідентичності";
    if (at >= 0x32 && at <= 0x33)   return "МІТКА 3 (доби)";
    if (at >= 0x38 && at <= 0x39)   return "шунт";
    if (at >= 0x3C && at <= 0x3D)   return "лічильник заряду CCA";
    if (at >= 0x3E && at <= 0x3F)   return "лічильник розряду DCA";
    return "";                      // саме порожньо: невідоме лишається невідомим
}

inline const char *snapName33(int at) {
    if (at < 0x020)                 return "заголовок";
    if (at >= 0x021 && at < 0x041)  return "профіль моделі";
    if (at >= 0x0E0 && at < 0x100)  return "COPYRIGHT";
    if (at >= 0x129 && at < 0x140)  return "заводська таблиця";
    if (at >= 0x148 && at < 0x153)  return "запис моделі";
    if (at >= 0x18A)                return "навчений хвіст";
    return "";
}

#endif // SNAPSHOT_DIFF_H
