#pragma once
// ===========================================================================
//  battbar.h — КОЛИ ШКАЛУ БАТАРЕЇ ТРЕБА ПЕРЕМАЛЬОВУВАТИ, А КОЛИ НІ
// ===========================================================================
//  Скарга: під час заряду/розряду анімована шкала «скидається» на кожному
//  опитуванні — раз на секунду видно спалах рівного кольору замість плавного
//  градієнта, що біжить.
//
//  Причина не в анімації, а в тому, що її щоразу СТИРАЛИ. Сторінка заряду на
//  кожному опитуванні робила так:
//
//      tft.fillRect(0, by - 2, TFT_W, bh + 4, C_BG);   // затерти смугу у фон
//      drawBatteryBar(...);                            // намалювати РІВНУ заливку
//
//  Далі displayAnimTick() (~9 к/с) знову клав градієнт поверх. Тобто кожної
//  секунди картинка на мить поверталась до рівного кольору — рівно те, що
//  читається як «скинулось».
//
//  ⚑ І ПЕРЕМАЛЬОВУВАТИ БУЛО НІ ДО ЧОГО. Напруга змінюється щосекунди, але
//  ГРАФІЧНИЙ рівень — ні: шкала завширшки 200 px має всього 100 різних
//  положень заповнення, тож зміна на 1 % часто не рухає жодного пікселя, а
//  зміна на 10 мВ не рухає навіть відсотка. Малювати те саме — це не «зайва
//  робота», це видимий дефект.
//
//  Тому рішення «малювати чи ні» ухвалюється за ГРАФІЧНИМ станом: ширина
//  заповнення в пікселях, колір і геометрія. Тут воно чистою функцією — щоб
//  його міг перевірити хостовий тест (display_color.h на хості не збирається).
// ===========================================================================

#include <stdint.h>

// Ширина заповнення шкали в ПІКСЕЛЯХ. Це і є «графічний рівень показання»:
// саме він, а не відсоток і не мілівольти, вирішує, чи зміниться картинка.
//  barW  — повна ширина рамки;
//  inset — сумарний відступ заливки від країв (по 3 px з боку -> 6);
//  pct   — 0..100, від'ємне = «даних немає».
inline int battFillW(int barW, int pct, int inset) {
    if (pct < 0) return -1;                    // немає даних — окремий стан
    int avail = barW - inset;
    if (avail < 0) avail = 0;
    if (pct > 100) pct = 100;
    int fw = avail * pct / 100;
    if (fw < 0) fw = 0;
    if (fw > avail) fw = avail;
    return fw;
}

// Те, що вже намальовано на екрані. gen — «покоління» екрана: його міняють
// щоразу, коли екран (або тіло сторінки) очищають повністю. Без цього кеш
// брехав би після fillScreen(): стан «той самий», а пікселів уже немає.
struct BattBarDrawn {
    int      x = -1, y = -1, w = -1, h = -1;
    int      fw = -2;              // -2 = ще нічого не малювали, -1 = «даних немає»
    uint16_t col = 0;
    uint32_t gen = 0;
};

// ── КОЛІР ЗАЛИВКИ: ПЛАВНО ВІД ЧЕРВОНОГО ДО ЗЕЛЕНОГО ───────────────────────
//  Було три сходинки: <30 % червоний, <60 % жовтий, далі зелений. На межі
//  колір стрибав, і два сусідніх показання (29 і 30 %) виглядали як різні
//  стани пакета, хоча різниці між ними немає. Тепер колір — НЕПЕРЕРВНА
//  функція заряду: 0 % чистий червоний, 100 % чистий зелений.
//
//  ⚑ ЧОМУ ЧЕРЕЗ ЖОВТИЙ, А НЕ НАВПРОСТЕЦЬ. Пряма інтерполяція між червоним
//  (255,0,0) і зеленим (0,255,0) на половині дає (128,128,0) — темну оливу,
//  удвічі тьмянішу за обидва кінці. Тобто шкала на 50 % світилася б слабше,
//  ніж на 0 % і на 100 %, і «майже порожньо» читалось би яскравіше за
//  «половина». Тому йдемо двома відрізками через ЖОВТИЙ (255,255,0): яскравість
//  лишається сталою на всій шкалі, а відтінок рівно перетікає.
//
//  Повертає RGB565. pct < 0 («даних немає») тут не обробляється навмисно: це
//  не рівень заряду, і колір для нього обирає сторінка (приглушений сірий).
inline uint16_t battFillColor(int pct) {
    if (pct < 0)   pct = 0;
    if (pct > 100) pct = 100;
    int r, g;
    if (pct <= 50) { r = 255;             g = 255 * pct / 50; }        // червоний -> жовтий
    else           { r = 255 * (100 - pct) / 50; g = 255; }            // жовтий  -> зелений
    return (uint16_t)(((r & 0xF8) << 8) | ((g & 0xFC) << 3));          // синього немає взагалі
}

// Чи змінилось хоч що-небудь із того, що видно на екрані.
//
//  ⚑ ПОРІВНЮЄМО САМЕ fw, А НЕ pct. Це не оптимізація заради оптимізації:
//  на pct шкала перемальовувалась би там, де жоден піксель не рухається, —
//  тобто дефект зі скарги нікуди б не подівся, просто рідше.
inline bool battBarChanged(const BattBarDrawn &d,
                           int x, int y, int w, int h,
                           int fw, uint16_t col, uint32_t gen) {
    return d.gen != gen || d.x != x || d.y != y || d.w != w || d.h != h ||
           d.fw != fw || d.col != col;
}
