#ifndef COMBO_H
#define COMBO_H
// ===========================================================================
//  combo.h — ПРИХОВАНІ ЖЕСТИ КНОПКАМИ (чиста логіка, без екрана й Arduino)
// ===========================================================================
//  У пристрою три кнопки, і всі три вже зайняті звичайною навігацією. Коли
//  треба ще один вхід — увімкнути чи вимкнути цілу функцію, — окремої кнопки
//  для нього немає й не буде. Такий вхід роблять ЖЕСТОМ, який неможливо
//  зробити випадково, гортаючи меню.
//
//  Тут лежить рівно те, що можна перевірити на хості: коли жест вважається
//  зробленим, а коли ні. Обидва драйвери екрана (display.h і display_color.h)
//  на хості не збираються, тому все, що вміє жити окремо від них, живе окремо.
//
//  ⚑ ЖЕСТИ ТУТ ДВОХ РІЗНИХ ПОРІД, І ЦЕ НАВМИСНО.
//
//  УТРИМАННЯ — для того, що людина робить свідомо й дивлячись на екран:
//  вимикач заряду. Екран на кожній сходинці каже, що буде, якщо відпустити
//  зараз, тож помилитись важко.
//
//  ПОСЛІДОВНІСТЬ — для прихованого. Її навмисно НЕ підказують: жест, про який
//  екран сам розповідає, перестає бути прихованим. Ціна — його треба знати
//  напам'ять, і саме тому в нього є вікно часу: недобраний ланцюжок не сміє
//  лежати в пам'яті приладу годинами й доганяти людину через півдня.
//
//  ⚑ ІСТОРІЯ, ЩОБ НЕ ХОДИТИ ПО КОЛУ. Спершу тут був ланцюжок із допуском
//  темпу (кожне натискання мусило встигнути за попереднім); власник замінив
//  його на утримання; тепер повернувся ланцюжок, але з ОДНИМ вікном на весь
//  жест, а не з допуском між сусідніми натисканнями. Різниця істотна: допуск
//  темпу карає за паузу посеред правильно набраного жесту, вікно — ні. Старої
//  механіки (відкат Кнута—Морріса—Пратта, межі темпу) не повертали: для
//  ланцюжка з п'яти клавіш вона не потрібна, а мертвий код, який виглядає
//  продуманим, не викликає підозр і живе роками.
//
//  ⚑ ДВА ПОРОГИ НА ОДНОМУ НАТИСКАННІ, А НЕ ДВІ КНОПКИ. Кнопок для другого
//  жесту просто немає. Тому жест один — «тримати», — а розрізняє їх ЧАС; і
//  саме тому рішення про заряд ухвалюється НА ВІДПУСКАННІ, а не на порозі:
//  інакше дорога до другого жесту проходила б через перший, і кожен, хто
//  дотримав до кінця, дорогою вимикав би собі заряд.
// ===========================================================================

#include <stdint.h>

// ── СХОДИ ПОРОГІВ ─────────────────────────────────────────────────────────
//  Три числа однієї шкали, тому вони й лежать разом: звичайне «довге»
//  натискання, поріг вимикача заряду, поріг прихованого повідомлення.
#ifndef COMBO_LONG_MS
  #define COMBO_LONG_MS 800u          // звичайне довге натискання
#endif
#ifndef COMBO_HOLD_CHARGE_MS
  #define COMBO_HOLD_CHARGE_MS 5000u  // задано власником: 5 с
#endif

// ⚑ ВІДСТАНІ МІЖ СХОДИНКАМИ — НЕ ПЕДАНТИЗМ, А ЄДИНЕ, ЩО РОЗДІЛЯЄ ЖЕСТИ.
//  Знизу: звичайне довге натискання виконує операцію (скидання, ремонт,
//  очистка). Якщо поріг заряду підповзе до нього, людина, яка просто тримає
//  OK заради «ПУСК», дорогою перемкне собі заряд — і не зрозуміє, що зробила.
//  Посередині: між порогами треба встигнути ВІДПУСТИТИ, інакше зупинитись на
//  заряді неможливо в принципі. Зверху: жест, який вимагає тримати кнопку
//  півхвилини, ніхто не дотримає — його просто вважатимуть непрацюючим.
#if (COMBO_HOLD_CHARGE_MS) < (COMBO_LONG_MS) + 2000u
  #error "COMBO_HOLD_CHARGE_MS замало відсунутий від COMBO_LONG_MS: звичайне утримання «ПУСК» дорогою перемкне заряд."
#endif
#if (COMBO_HOLD_CHARGE_MS) > 30000u
  #error "COMBO_HOLD_CHARGE_MS завеликий: такий жест ніхто не дотримає, і його вважатимуть непрацюючим."
#endif

// ── ЩО ПОВЕРТАЄ ДЕТЕКТОР ──────────────────────────────────────────────────
//  Драйверів екрана два, і жоден не збирається на хості. Якби кожен вирішував
//  сам, коли жест зроблено, правило існувало б у двох копіях — і розійшлося б
//  на першій же правці. Тому рішення тут, а драйвери лише виконують його.
enum {
    CHOLD_NONE       = 0,   // нічого не сталось
    CHOLD_SHORT      = 1,   // відпущено до COMBO_LONG_MS — звичайне коротке
    CHOLD_LONG       = 2,   // відпущено після COMBO_LONG_MS — звичайне довге
    CHOLD_ARM_LONG   = 3,   // минув COMBO_LONG_MS, кнопку ще тримають
    CHOLD_ARM_CHARGE = 4,   // минув поріг заряду, кнопку ще тримають
    CHOLD_CHARGE     = 5,   // відпущено після порога заряду
};

// Сходинка, на якій зараз стоїть утримання.
enum { CHS_SHORT = 0, CHS_LONG = 1, CHS_CHARGE = 2 };

struct ComboHold { uint32_t t0 = 0; uint8_t stage = CHS_SHORT; bool down = false; };

// Подати ПРОТРЯСЕНИЙ стан кнопки (true = натиснута) на кожному проході.
//
//  ⚑ ARM-події існують не для краси. П'ять секунд, протягом яких нічого не
//  відбувається, людина читає як «не працює» і кнопку відпускає. Тому на
//  кожній сходинці детектор каже про це драйверові, а той пише на екран, що
//  саме буде, якщо відпустити зараз.
//
//  ⚑ УСІ СХОДИНКИ ВИРІШУЮТЬСЯ НА ВІДПУСКАННІ, і це та сама причина: інакше
//  дорога до верхньої проходила б через уже виконану нижню.
inline uint8_t comboHoldFeed(ComboHold &h, uint32_t now, bool down) {
    if (!down) {
        if (!h.down) return CHOLD_NONE;
        uint8_t st = h.stage;
        h.down = false;
        h.stage = CHS_SHORT;
        return st == CHS_CHARGE ? CHOLD_CHARGE
             : st == CHS_LONG   ? CHOLD_LONG
                                : CHOLD_SHORT;
    }
    if (!h.down) { h.down = true; h.t0 = now; h.stage = CHS_SHORT; return CHOLD_NONE; }
    uint32_t held = (uint32_t)(now - h.t0);
    if (h.stage < CHS_CHARGE && held >= (COMBO_HOLD_CHARGE_MS)) { h.stage = CHS_CHARGE; return CHOLD_ARM_CHARGE; }
    if (h.stage < CHS_LONG   && held >= (COMBO_LONG_MS))        { h.stage = CHS_LONG;   return CHOLD_ARM_LONG; }
    return CHOLD_NONE;
}

// Забути про поточне натискання. Кличеться, коли кнопка на цьому екрані
// належить не жестам, а аварійній зупинці: інакше утримання, почате під час
// операції, дорахувалось би вже в меню.
//
//  Після скидання ВІДПУСКАННЯ не породжує події (h.down уже false) — і це
//  правильно: натискання, яким володів інший обробник, не сміє наприкінці
//  віддати «коротке» ще й сюди.
inline void comboHoldReset(ComboHold &h) { h.down = false; h.stage = CHS_SHORT; h.t0 = 0; }

// ── ПОСЛІДОВНІСТЬ КЛАВІШ ──────────────────────────────────────────────────
//  Другий вид жесту: не «тримати», а НАБРАТИ. Кнопок так само три, тож
//  клавіші ті самі, якими гортають меню, — і саме тому жест мусить бути
//  таким, який неможливо набрати випадково, гортаючи список.
//
//  ⚑ ВІКНО НА ВЕСЬ ЖЕСТ, А НЕ ДОПУСК МІЖ НАТИСКАННЯМИ. Це рішення власника
//  («ввід команди протягом 5 секунд»), і воно ще й простіше пояснюється:
//  почав набирати — маєш 5 секунд на весь ланцюжок. Допуск між сусідніми
//  натисканнями виглядає схоже, але поводиться інакше — карає за одну паузу
//  посеред правильно набраного жесту, і людина не розуміє, чому «те саме» то
//  працює, то ні.
//
//  ⚑ ЛІЧИЛЬНИК НЕ ЖИВЕ ВІЧНО. Без вікна половина жесту лежала б у пам'яті
//  приладу до наступного натискання — хоч і через годину. Тоді три випадкові
//  натискання зранку й два ввечері складались би в жест, і виглядало б це як
//  самочинне спрацювання.
enum { CKEY_NONE = 0, CKEY_LEFT = 1, CKEY_RIGHT = 2, CKEY_ENTER = 3 };

#ifndef COMBO_SEQ_WINDOW_MS
  #define COMBO_SEQ_WINDOW_MS 5000u   // задано власником: 5 с на весь жест
#endif

// Сам ланцюжок: «‹ ‹ › › › › ‹ ‹ ›». Дев'ять клавіш, «OK» серед них немає —
// отже жест можна набрати де завгодно, нічого дорогою не запустивши.
static const uint8_t COMBO_SEQ[] = { CKEY_LEFT,  CKEY_LEFT,
                                     CKEY_RIGHT, CKEY_RIGHT, CKEY_RIGHT, CKEY_RIGHT,
                                     CKEY_LEFT,  CKEY_LEFT,  CKEY_RIGHT };
#define COMBO_SEQ_LEN ((uint8_t)(sizeof(COMBO_SEQ) / sizeof(COMBO_SEQ[0])))

struct ComboSeq { uint8_t n = 0; uint32_t t0 = 0; };

inline void comboSeqReset(ComboSeq &s) { s.n = 0; s.t0 = 0; }

// Скинути недобраний ланцюжок, якщо вікно вийшло.
//
//  ⚑ ОДНА РЕАЛІЗАЦІЯ, ДВА ВХОДИ. Драйвер кличе це щопроходу (щоб лічильник
//  гаснув сам, а не «на наступному натисканні»), і те саме робить
//  comboSeqFeed() перед розбором клавіші. Написати перевірку часу двічі —
//  найпряміша дорога до «одне поле, два питання»: два відповідачі на питання
//  «чи вийшло вікно» розійшлися б першою ж правкою.
inline void comboSeqTick(ComboSeq &s, uint32_t now) {
    if (s.n && (uint32_t)(now - s.t0) > (COMBO_SEQ_WINDOW_MS)) comboSeqReset(s);
}

// ── ВІДКАТ ПІСЛЯ ОБМОВКИ ──────────────────────────────────────────────────
//  Скільки клавіш лишається зарахованими, коли натиснули НЕ ту.
//
//  ⚑ ЧОМУ НЕ «ПРОСТО ОБНУЛИТИ». Найзвичайніша обмовка — зайва клавіша посеред
//  правильного набору. Обнулення означало б, що після неї жест доводиться
//  починати з нуля, хоч частина вже набраного лишається правильним початком.
//
//  ⚑ І ЧОМУ НЕ «ПОЧАТИ ЗАНОВО ЦІЄЮ Ж КЛАВІШЕЮ». Так було зроблено для
//  попереднього ланцюжка, і для НЬОГО цього справді вистачало: жоден його
//  хвіст, крім однієї клавіші, не був його ж початком. У нового це не так —
//  «‹ ‹» наприкінці є його власним початком. Порахуємо для «‹ ‹ › › › › ‹ ‹ ›»:
//  набрано вісім («‹ ‹ › › › › ‹ ‹»), дев'ятою мало бути «›», а натиснули «‹».
//  Правильна відповідь — ДВІ зараховані клавіші («‹ ‹» — хвіст, який є
//  початком), і жест добирається рештою. Спрощений відкат лишив би одну, і
//  набір «‹ ‹ › › › › ‹ ‹ ‹ › › › › ‹ ‹ ›» не спрацював би НІКОЛИ.
//
//  Це те саме, що робить таблиця Кнута—Морріса—Пратта, тільки без таблиці:
//  для дев'яти клавіш прямий перебір коштує десятки порівнянь раз на
//  натискання — а таблиця, яку ніхто не читає очима, коштувала б помилки в ній.
//
//  Уже набране — це завжди COMBO_SEQ[0..n-1], тож зберігати історію не треба:
//  шукаємо найдовший суфікс «набране + клавіша», який є початком ланцюжка.
inline uint8_t comboSeqAfterMiss(uint8_t n, uint8_t key) {
    for (uint8_t s = n; s > 0; s--) {          // s — довжина нового збігу
        if (COMBO_SEQ[s - 1] != key) continue; // остання клавіша нового збігу
        bool ok = true;
        for (uint8_t i = 0; i + 1 < s; i++)
            if (COMBO_SEQ[n - (s - 1) + i] != COMBO_SEQ[i]) { ok = false; break; }
        if (ok) return s;
    }
    return (uint8_t)((key == COMBO_SEQ[0]) ? 1 : 0);
}

// Подати натиснуту клавішу. true — РІВНО на тому натисканні, яким жест
// завершено; після цього лічильник обнуляється сам.
//
//  ⚑ ПІСЛЯ СПРАЦЮВАННЯ ЛІЧИЛЬНИК САМЕ ОБНУЛЯЄТЬСЯ, А НЕ ВІДКОЧУЄТЬСЯ. Хвіст
//  цього ланцюжка («‹ ‹ ›») теж є його початком, тож із відкатом жест
//  спрацьовував би вдруге вже за шість клавіш після першого разу. Показувати
//  напис двічі поспіль — це вигляд несправності, а не жарт.
inline bool comboSeqFeed(ComboSeq &s, uint32_t now, uint8_t key) {
    if (key == CKEY_NONE) return false;
    comboSeqTick(s, now);
    if (key == COMBO_SEQ[s.n]) {
        if (s.n == 0) s.t0 = now;
        if (++s.n >= COMBO_SEQ_LEN) { comboSeqReset(s); return true; }
        return false;
    }
    //  ⚑ ВІДКАТ НЕ ПРОДОВЖУЄ ВІКНО. Клавіші, які лишились зарахованими, були
    //  натиснуті РАНІШЕ — десь між t0 і зараз. Поставити відлік наново
    //  означало б, що кожна обмовка дарує ще п'ять секунд, і жест, набраний за
    //  півхвилини з помилками, усе одно зарахувався б. Тому початок відліку
    //  лишається той самий: «п'ять секунд на весь ввід» — це п'ять секунд від
    //  першої клавіші, а не від останньої обмовки.
    uint8_t back = comboSeqAfterMiss(s.n, key);
    uint32_t t0 = s.t0;
    comboSeqReset(s);
    if (back) { s.n = back; s.t0 = t0; }
    return false;
}

// ── ПОВНОЕКРАННЕ ПОВІДОМЛЕННЯ НА ЗАДАНИЙ ЧАС ──────────────────────────────
#ifndef COMBO_FLASH_MS
  #define COMBO_FLASH_MS 5000u
#endif

struct ComboFlash { uint32_t until = 0; };

inline void comboFlashArm(ComboFlash &f, uint32_t now, uint32_t ms) {
    f.until = now + ms;
    if (f.until == 0) f.until = 1;      // 0 зарезервовано під «не показуємо»
}
inline bool comboFlashActive(const ComboFlash &f, uint32_t now) {
    return f.until != 0 && (int32_t)(now - f.until) < 0;
}
// true РІВНО ОДИН РАЗ — на тому проході, коли час вийшов. Саме на ньому
// драйвер і перемальовує екран назад; питати «чи вже минуло» щопроходу й
// перемальовувати щоразу означало б вічну перемальовку.
inline bool comboFlashExpired(ComboFlash &f, uint32_t now) {
    if (f.until == 0) return false;
    if ((int32_t)(now - f.until) < 0) return false;
    f.until = 0;
    return true;
}

#endif // COMBO_H
