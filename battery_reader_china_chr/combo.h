#ifndef COMBO_H
#define COMBO_H
// ===========================================================================
//  combo.h — ПРИХОВАНІ ЖЕСТИ КНОПКАМИ (чиста логіка, без екрана й Arduino)
// ===========================================================================
//  У пристрою три кнопки, і всі три вже зайняті звичайною навігацією. Коли
//  треба ще один вхід — увімкнути чи вимкнути цілу функцію, — окремої кнопки
//  для нього немає й не буде. Такий вхід роблять ЖЕСТОМ, який неможливо
//  зробити випадково, гортаючи меню.
//
//  Тут лежить рівно те, що можна перевірити на хості: коли жест вважається
//  зробленим, а коли ні. Обидва драйвери екрана (display.h і display_color.h)
//  на хості не збираються, тому все, що вміє жити окремо від них, живе окремо.
//
//  ⚑ БУЛО: ЛАНЦЮЖОК КОРОТКИХ НАТИСКАНЬ. Чотири швидкі натискання перемикали
//  вимикач заряду, послідовність «‹ ‹ › › ‹ ‹ OK» показувала приховане
//  повідомлення. Власник замінив обидва на УТРИМАННЯ однієї кнопки. Причина
//  видна з самої заміни: ланцюжок треба набрати з темпом і нічим при цьому не
//  керуватись, а утримання — просто тримати й дивитись на екран, який сам
//  каже, що буде далі. Разом із ланцюжками пішла й уся їхня механіка — лік
//  натискань, відкат Кнута—Морріса—Пратта, допуск темпу з його межами.
//  Тримати її «про запас» було б гірше, ніж не мати: мертвий код, який
//  виглядає продуманим, не викликає підозр і живе роками.
//
//  ⚑ ДВА ПОРОГИ НА ОДНОМУ НАТИСКАННІ, А НЕ ДВІ КНОПКИ. Кнопок для другого
//  жесту просто немає. Тому жест один — «тримати», — а розрізняє їх ЧАС; і
//  саме тому рішення про заряд ухвалюється НА ВІДПУСКАННІ, а не на порозі:
//  інакше дорога до другого жесту проходила б через перший, і кожен, хто
//  дотримав до кінця, дорогою вимикав би собі заряд.
// ===========================================================================

#include <stdint.h>

// ── СХОДИ ПОРОГІВ ─────────────────────────────────────────────────────────
//  Три числа однієї шкали, тому вони й лежать разом: звичайне «довге»
//  натискання, поріг вимикача заряду, поріг прихованого повідомлення.
#ifndef COMBO_LONG_MS
  #define COMBO_LONG_MS 800u          // звичайне довге натискання
#endif
#ifndef COMBO_HOLD_CHARGE_MS
  #define COMBO_HOLD_CHARGE_MS 5000u  // задано власником: 5 с
#endif
#ifndef COMBO_HOLD_FLASH_MS
  #define COMBO_HOLD_FLASH_MS 10000u  // задано власником: 10 с
#endif

// ⚑ ВІДСТАНІ МІЖ СХОДИНКАМИ — НЕ ПЕДАНТИЗМ, А ЄДИНЕ, ЩО РОЗДІЛЯЄ ЖЕСТИ.
//  Знизу: звичайне довге натискання виконує операцію (скидання, ремонт,
//  очистка). Якщо поріг заряду підповзе до нього, людина, яка просто тримає
//  OK заради «ПУСК», дорогою перемкне собі заряд — і не зрозуміє, що зробила.
//  Посередині: між порогами треба встигнути ВІДПУСТИТИ, інакше зупинитись на
//  заряді неможливо в принципі. Зверху: жест, який вимагає тримати кнопку
//  півхвилини, ніхто не дотримає — його просто вважатимуть непрацюючим.
#if (COMBO_HOLD_CHARGE_MS) < (COMBO_LONG_MS) + 2000u
  #error "COMBO_HOLD_CHARGE_MS замало відсунутий від COMBO_LONG_MS: звичайне утримання «ПУСК» дорогою перемкне заряд."
#endif
#if (COMBO_HOLD_FLASH_MS) < (COMBO_HOLD_CHARGE_MS) + 3000u
  #error "COMBO_HOLD_FLASH_MS замало відсунутий від порога заряду: на цій сходинці неможливо зупинитись."
#endif
#if (COMBO_HOLD_FLASH_MS) > 30000u
  #error "COMBO_HOLD_FLASH_MS завеликий: такий жест ніхто не дотримає, і його вважатимуть непрацюючим."
#endif

// ── ЩО ПОВЕРТАЄ ДЕТЕКТОР ──────────────────────────────────────────────────
//  Драйверів екрана два, і жоден не збирається на хості. Якби кожен вирішував
//  сам, коли жест зроблено, правило існувало б у двох копіях — і розійшлося б
//  на першій же правці. Тому рішення тут, а драйвери лише виконують його.
enum {
    CHOLD_NONE       = 0,   // нічого не сталось
    CHOLD_SHORT      = 1,   // відпущено до COMBO_LONG_MS — звичайне коротке
    CHOLD_LONG       = 2,   // відпущено після COMBO_LONG_MS — звичайне довге
    CHOLD_ARM_LONG   = 3,   // минув COMBO_LONG_MS, кнопку ще тримають
    CHOLD_ARM_CHARGE = 4,   // минув поріг заряду, кнопку ще тримають
    CHOLD_CHARGE     = 5,   // відпущено між порогом заряду й порогом нижче
    CHOLD_FLASH      = 6,   // дотримали до останнього порога
};

// Сходинка, на якій зараз стоїть утримання.
enum { CHS_SHORT = 0, CHS_LONG = 1, CHS_CHARGE = 2, CHS_FLASH = 3 };

struct ComboHold { uint32_t t0 = 0; uint8_t stage = CHS_SHORT; bool down = false; };

// Подати ПРОТРЯСЕНИЙ стан кнопки (true = натиснута) на кожному проході.
//
//  ⚑ ARM-події існують не для краси. П'ять секунд, протягом яких нічого не
//  відбувається, людина читає як «не працює» і кнопку відпускає. Тому на
//  кожній сходинці детектор каже про це драйверові, а той пише на екран, що
//  саме буде, якщо відпустити зараз.
//
//  ⚑ ОСТАННЯ СХОДИНКА СПРАЦЬОВУЄ ОДРАЗУ, А НЕ НА ВІДПУСКАННІ, і це не
//  непослідовність: до неї треба ДОТРИМАТИ, тобто вона й так вимірюється
//  порогом, а не відпусканням. Після неї відпускання вже нічого не означає —
//  інакше воно ще й перемкнуло б заряд.
inline uint8_t comboHoldFeed(ComboHold &h, uint32_t now, bool down) {
    if (!down) {
        if (!h.down) return CHOLD_NONE;
        uint8_t st = h.stage;
        h.down = false;
        h.stage = CHS_SHORT;
        return st == CHS_FLASH  ? CHOLD_NONE       // повідомлення вже показане
             : st == CHS_CHARGE ? CHOLD_CHARGE
             : st == CHS_LONG   ? CHOLD_LONG
                                : CHOLD_SHORT;
    }
    if (!h.down) { h.down = true; h.t0 = now; h.stage = CHS_SHORT; return CHOLD_NONE; }
    uint32_t held = (uint32_t)(now - h.t0);
    if (h.stage < CHS_FLASH  && held >= (COMBO_HOLD_FLASH_MS))  { h.stage = CHS_FLASH;  return CHOLD_FLASH; }
    if (h.stage < CHS_CHARGE && held >= (COMBO_HOLD_CHARGE_MS)) { h.stage = CHS_CHARGE; return CHOLD_ARM_CHARGE; }
    if (h.stage < CHS_LONG   && held >= (COMBO_LONG_MS))        { h.stage = CHS_LONG;   return CHOLD_ARM_LONG; }
    return CHOLD_NONE;
}

// Забути про поточне натискання. Кличеться, коли кнопка на цьому екрані
// належить не жестам, а аварійній зупинці: інакше утримання, почате під час
// операції, дорахувалось би вже в меню.
//
//  Після скидання ВІДПУСКАННЯ не породжує події (h.down уже false) — і це
//  правильно: натискання, яким володів інший обробник, не сміє наприкінці
//  віддати «коротке» ще й сюди.
inline void comboHoldReset(ComboHold &h) { h.down = false; h.stage = CHS_SHORT; h.t0 = 0; }

// ── ПОВНОЕКРАННЕ ПОВІДОМЛЕННЯ НА ЗАДАНИЙ ЧАС ──────────────────────────────
#ifndef COMBO_FLASH_MS
  #define COMBO_FLASH_MS 5000u
#endif

struct ComboFlash { uint32_t until = 0; };

inline void comboFlashArm(ComboFlash &f, uint32_t now, uint32_t ms) {
    f.until = now + ms;
    if (f.until == 0) f.until = 1;      // 0 зарезервовано під «не показуємо»
}
inline bool comboFlashActive(const ComboFlash &f, uint32_t now) {
    return f.until != 0 && (int32_t)(now - f.until) < 0;
}
// true РІВНО ОДИН РАЗ — на тому проході, коли час вийшов. Саме на ньому
// драйвер і перемальовує екран назад; питати «чи вже минуло» щопроходу й
// перемальовувати щоразу означало б вічну перемальовку.
inline bool comboFlashExpired(ComboFlash &f, uint32_t now) {
    if (f.until == 0) return false;
    if ((int32_t)(now - f.until) < 0) return false;
    f.until = 0;
    return true;
}

#endif // COMBO_H
