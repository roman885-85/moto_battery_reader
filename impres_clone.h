#ifndef IMPRES_CLONE_H
#define IMPRES_CLONE_H
// ===========================================================================
//  ВІДНОВЛЕННЯ ЗА ЗРАЗКОМ КИТАЙСЬКОЇ КОПІЇ — крайній засіб
// ---------------------------------------------------------------------------
//  Коли жодна спроба відновлення не вдалася, лишається шлях, яким ідуть самі
//  копії: уся потрібна рації інформація живе в DS2438, а DS2433 порожній.
//
//  ⚑ ЧОМУ ЦЕ ПРАЦЮЄ. Сторінки 3..6 монітора — це ДЗЕРКАЛО заголовка DS2433:
//  DS2438[0x18..0x32] побайтово дорівнює DS2433[0x01..0x1B] (звірено на рідній
//  парі 4409B — 27 із 27 байт; останні п'ять байтів заголовка в дзеркало не
//  входять). Перевірено й на дампі реальної копії, наданому власником:
//
//     дзеркало  50 01 01 00 00 C7 53 56 05 C2 2D ...
//     заголовок 8D 50 01 01 00 00 C7 53 56 05 C2 2D ...   (зсув +1)
//
//  Серед цих байтів — і паспортна ємність (DS2433[0x008]): у тому дампі 0x56
//  = 86, тобто 86 × 25 = 2150 мА·год. Тому копія з ПОРОЖНІМ DS2433 усе одно
//  повідомляє рації свою ємність, шунт (DS2438[56..57]) і OFFSET АЦП — усе з
//  монітора. Ніякого синтезу DS2433 для цього не потрібно.
//
//  Чого в цьому режимі НЕМАЄ: моделі, дат, зносу, лічильників калібрування —
//  вони живуть у блоках DS2433, а він порожній. Запис ідентичності в DS2433 —
//  окремий, ОПЦІЙНИЙ і ЕКСПЕРИМЕНТАЛЬНИЙ крок (див. web_server.h): каркас
//  береться з еталона родини 4409, бо саме її шунт (45.65 мОм) несе монітор
//  копії.
//
//  Файл — чиста арифметика без вводу-виводу, щоб той самий код ганявся й у
//  тестах на дампах.
// ===========================================================================
#include <stdint.h>
#include <string.h>
#include "impres_format.h"
#include "impres_bms.h"

// Дзеркало заголовка в моніторі: DS2438[MIRROR_AT + k - 1] == DS2433[k].
// ⚑ Збігається НЕ ввесь заголовок, а перші 27 байт — DS2433[0x01..0x1B].
// Останні п'ять (0x1C..0x20) у кожного чипа свої: на рідній парі 4409B саме
// вони й розходяться, тоді як решта збігається побайтово. Байт паспортної
// ємності (0x008) — усередині збіжної частини, тому з дзеркала він читається
// надійно: на тій же парі дзеркало дає 2150 мА·год, і DS2433 дає 2150.
#define CLONE_MIRROR_AT   0x18
#define CLONE_MIRROR_LEN  27

// Куди в моніторі лягає байт паспортної ємності (DS2433[0x008]).
#define CLONE_RATED_AT    (CLONE_MIRROR_AT + IMPRES_RATED_BYTE - 1)

// Прочитати паспортну ємність із дзеркала монітора, мА·год. 0 — дзеркала
// немає (усе нулі або 0xFF), тобто монітор не від копії такого роду.
inline int impresCloneRatedFrom38(const uint8_t *d38) {
    if (!d38) return 0;
    uint8_t b = d38[CLONE_RATED_AT];
    if (b == 0x00 || b == 0xFF) return 0;
    long mah = (long)b * IMPRES_RATED_STEP;
    if (mah < IMPRES_RATED_MIN_MAH || mah > IMPRES_RATED_MAX_MAH) return 0;
    return (int)mah;
}

// Чи несе цей монітор дзеркало заголовка взагалі. У «звичайних» пакетів
// сторінки 3..6 теж дзеркало, але в частини екземплярів вони нульові — тоді
// брати з них ємність не можна.
inline bool impresCloneMirrorPresent(const uint8_t *d38) {
    if (!d38) return false;
    bool all0 = true, allFF = true;
    for (int i = 0; i < CLONE_MIRROR_LEN; i++) {
        uint8_t b = d38[CLONE_MIRROR_AT + i];
        if (b != 0x00) all0 = false;
        if (b != 0xFF) allFF = false;
    }
    return !all0 && !allFF;
}

// Підготувати монітор за зразком копії.
//   dst      — куди складаємо (64 Б);
//   src38    — дамп монітора копії (64 Б);
//   ratedMah — паспортна ємність, яку вписав власник (0 — лишити з дзеркала);
//   rsRaw    — шунт, Ом×100000 (0 — лишити той, що в дампі);
//   ica      — паливомір із РЕАЛЬНОЇ напруги цього пакета.
// Лічильники (наробіток, CCA, DCA) обнуляються: пакет починає життя наново,
// а числа копії до наших банок стосунку не мають.
inline void impresCloneBuild38(uint8_t *dst, const uint8_t *src38,
                               int ratedMah, long rsRaw, uint8_t ica) {
    if (!dst || !src38) return;
    memcpy(dst, src38, DS2438_MEM_SIZE);

    // Наробіток і лічильники заряду/розряду — у нуль.
    dst[8] = dst[9] = dst[10] = dst[11] = 0;      // ETM
    dst[60] = dst[61] = 0;                        // CCA
    dst[62] = dst[63] = 0;                        // DCA
    dst[12] = ica;                                // ICA з поточної напруги

    // Паспортна ємність — у дзеркало заголовка; саме звідти рація її й читає,
    // коли DS2433 порожній.
    if (ratedMah > 0) {
        long b = (ratedMah + IMPRES_RATED_STEP / 2) / IMPRES_RATED_STEP;
        if (b > 0 && b < 256) dst[CLONE_RATED_AT] = (uint8_t)b;
    }
    // Шунт: свій із дампа, або обраний зі списку типових, коли невідомий.
    if (rsRaw > 0) {
        dst[56] = (uint8_t)(rsRaw & 0xFF);
        dst[57] = (uint8_t)((rsRaw >> 8) & 0xFF);
    }
}

#endif // IMPRES_CLONE_H
